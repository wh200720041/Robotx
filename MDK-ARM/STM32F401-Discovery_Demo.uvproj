# Keil uVision project STM32F401-Discovery_Demo.uvproj, settings and files
target STM32F401C-DISCO (ARM-ADS)
  device: STM32F401VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: STM32F401C-DISCO +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,USE_USB_OTG_FS,USE_STM32F401,I2S_INTERRUPT,
  c include: .\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\Libraries\CMSIS\Include;.\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;.\..\..\..\Utilities\STM32F401-Discovery;..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\Demonstration
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK-ARM
    ./../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group STM32_USB_Device_Library
    ./../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group STM32_USB_OTG_Driver
    ./../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32F401_Discovery
    ./../../../Utilities/STM32F401-Discovery/: stm32f401_discovery.c stm32f401_discovery_lsm303dlhc.c
    ../../../Utilities/STM32F401-Discovery/: stm32f401_discovery_l3gd20.c
  group STM32F4xx_StdPeriph_Driver
    ./../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group User
    ./../: main.c system_stm32f4xx.c usb_bsp.c usbd_desc.c usbd_usr.c
    ../: stm32fxxx_it.c usbd_cdc_vcp.c Motor.c Utility.c IMU.c ADC.c
    ./: Command Description.txt
